# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-H563ZI_OEMiROT_Loader (6210000::V6.21::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.3.0-B01
  cpu: CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\rot_tz_s_loader.bin"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H563xx,USE_HAL_DRIVER
  c include: ../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../Inc;../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/driver;../Secure_nsclib
  library: MicroLIB
  scatter file: stm32h563xx.sct
  group Doc
    ../: README.md
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Application/User
    ../Src/: com.c common.c fw_update_app.c low_level_device.c low_level_flash.c low_level_security.c main.c stm32h5xx_it.c ymodem.c
    ./: startup_stm32h563xx.s
software components: CMSIS:CORE 4.3.0
